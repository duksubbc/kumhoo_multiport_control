# IAR project Project.ewp, settings and files
configuration STM8S003 (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 2
  General.GenDataModel: 2
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x00
  ICCSTM8.CCDefines: STM8S003; MULTI_1CH; nMULTI_6CH; nHSE_VALUE=16000000
  ICCSTM8.CCIncludePath2: ; STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: relay_sub.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM8S005 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S005C6 STM8S005C6
  General.GenStackSize: 0x200
  ICCSTM8.CCDefines: STM8S005; HSE_VALUE=16000000; MULTI_6CH
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8s005c6.icf
configuration PD_Debug (STM8, debug)
  as the first configuration, except:
  General.GenCodeModel: 1
  General.GenDataModel: 1
  ICCSTM8.CCDefines: STM8S003; KUMHOO_PD; nMULTI_1CH; nMULTI_6CH; nHSE_VALUE=16000000
  OBJCOPY.OOCOutputFile: pd_1ch.s19
  ILINK.IlinkIcfFile: lnkstm8s003f3.icf
configuration PD_Release (STM8)
  as the first configuration, except:
configuration 1CH_Debug (STM8, debug)
  as the first configuration, except:
  General.GenCodeModel: 1
  General.GenDataModel: 1
  OBJCOPY.OOCOutputFile: kumhoo_1c.s19
  ILINK.IlinkIcfFile: lnkstm8s003f3.icf
configuration 1CH_Release (STM8, debug)
  as the first configuration, except:
configuration 6CH_Debug (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S005C6 STM8S005C6
  General.GenStackSize: 0x200
  ICCSTM8.CCDefines: STM8S005; HSE_VALUE=16000000; MULTI_6CH
  OBJCOPY.OOCOutputFile: Project.s19
  ILINK.IlinkIcfFile: lnkstm8s005c6.icf
configuration 6CH_Release (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S005C6 STM8S005C6
  General.GenStackSize: 0x200
  ICCSTM8.CCDefines: STM8S005; HSE_VALUE=16000000; MULTI_6CH
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8s005c6.icf
  group (top)
    ./: board.h buzzer.h buzzerNotimer.c includes.h ir.c ir.h key.c key.h led.c led.h main.c main.h protocol.h security.c security.h stm8s_conf.h stm8s_it.c stm8s_it.h uart.c
  group StdPeriph_Drivers
    STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_iwdg.c stm8s_tim1.c stm8s_tim4.c stm8s_uart1.c
    STM8S_StdPeriph_Driver/inc/: stm8s_flash.h stm8s_iwdg.h
