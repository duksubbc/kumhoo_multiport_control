# IAR project stm8bootloader.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003; HSE_VALUE=16000000
  ICCSTM8.CCIncludePath2: ..\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8bootloader.hex
  ILINK.IlinkOutputFile: stm8bootloader.out
  ILINK.IlinkIcfFile: lnkstm8s003f3.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Include Files
    ../inc/: main.h stm8s.h stm8s_conf.h stm8s_type.h
  group Source Files
    ../src/: main.c
    ./: stm8s_interrupt.s
